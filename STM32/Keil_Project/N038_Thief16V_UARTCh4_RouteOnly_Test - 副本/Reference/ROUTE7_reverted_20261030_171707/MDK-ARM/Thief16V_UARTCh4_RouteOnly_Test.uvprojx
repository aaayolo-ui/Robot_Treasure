# Keil uVision project Thief16V_UARTCh4_RouteOnly_Test.uvprojx, settings and files
target Thief16V_UARTCh4_RouteOnly_Test (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Thief16V_UARTCh4_RouteOnly_Test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Hardware;../Hardware/NCHD12;../System;../Control;../Algorithm/MapRoute;../Algorithm/SpeedPI;../Algorithm/GrayPosition;../Algorithm/GrayCoordinate;../User;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Algorithm/ThiefStrategy;../Algorithm/MapLocalization;../Algorithm/LaserMux
  asm include: ;../Algorithm/MapLocalization
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Hardware
    ../Hardware/: PowerSoundLight.c PowerSoundLight.h MotorDriver.c MotorDriver.h Encoder.c Encoder.h Key.c Key.h SoftI2C.c SoftI2C.h TFT.h JY61P.c JY61P.h LaserRx.c LaserRx.h UartRxDispatcher.c DriveOutputSnapshot.c DriveOutputSnapshot.h TreasureMotorSnapshot.c TreasureMotorSnapshot.h UartCh4.c UartCh4.h
    ../Hardware/NCHD12/: nchd12.c nchd12.h nchd12_rear.c nchd12_rear.h
  group System
    ../System/: UartDebug.c UartDebug.h SystemTime.c SystemTime.h ResetReason.c ResetReason.h
  group Control
    ../Control/: RoadHeadingControl.c RestartLineSearch.c Chassis.c Chassis.h NewFrontDriveMap.c NewFrontDriveMap.h ChassisSpeedControl.c ChassisSpeedControl.h LineFollowPID.c LineFollowPID.h FollowSmoothing.c TravelFrame.c TravelFrame.h FollowSmoothing.h
  group User
    ../User/: App_ThiefStrategy.c App_ThiefStrategy.h LineFollowLog.c LineFollowLog.h TftRoutePage.h MapTimingLog.c MapRoutePosition.c ThiefTftPage.h StartupWheelLog.c StartupWheelLog.h TreasureWheelLog.c TreasureWheelLog.h
  group Algorithm
    ../Algorithm/GrayPosition/: gray_position.c gray_position.h
    ../Algorithm/GrayCoordinate/: gray_coordinate.c gray_coordinate.h
    ../Algorithm/SpeedPI/: WheelSpeedPi.c WheelSpeedPi.h
    ../Algorithm/MapRoute/: MapRouteNavigator.c MapRoutePlan.c TreasureGrayMask.c TreasureGrayMask.h
    ../Algorithm/ThiefStrategy/: ThiefMapPlanner.c ThiefMapPlanner.h FrontLaserGate.c FrontLaserGate.h ThiefInterceptPolicy.c ThiefPursuit.c ThiefPursuit.h ThiefRouteTrail.c ThiefRiskSearch.c ThiefRiskSearch.h ThiefThreatModel.c ThiefThreatModel.h ThiefRollout.h ThiefRolloutData.h ThiefMapTopology.h ThiefStrategyConfig.h
    ../Algorithm/MapLocalization/: ThiefLocalization.c ThiefLocalization.h TreasureLaserStart.c TreasureLaserStart.h MapLaserMask.c MapLaserMask.h
    ../Algorithm/LaserMux/: AI1811Mux.c AI1811Mux.h
software components: CMSIS:CORE 4.3.0

# Keil uVision project Infrared14A_LineFollow_ObstacleReverse_Test.uvprojx, settings and files
target Infrared14A_LineFollow_ObstacleReverse_Test (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Infrared14A_LineFollow_ObstacleReverse_Test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Hardware;../Hardware/NCHD12;../System;../Control;../Algorithm/SpeedPI;../Algorithm/GrayPosition;../Algorithm/GrayCoordinate;../User;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Hardware
    ../Hardware/: MotorDriver.c MotorDriver.h Encoder.c Encoder.h Key.c Key.h Infrared.c Infrared.h
    ../Hardware/NCHD12/: nchd12.c nchd12.h
  group System
    ../System/: UartDebug.c UartDebug.h SystemTime.c SystemTime.h
  group Control
    ../Control/: Chassis.c Chassis.h NewFrontDriveMap.c NewFrontDriveMap.h ChassisSpeedControl.c ChassisSpeedControl.h LineFollowP.c LineFollowP.h
  group User
    ../User/: App_InfraredLineFollowObstacleReverse.c App_InfraredLineFollowObstacleReverse.h
  group Algorithm
    ../Algorithm/GrayPosition/: gray_position.c gray_position.h
    ../Algorithm/GrayCoordinate/: gray_coordinate.c gray_coordinate.h
    ../Algorithm/SpeedPI/: WheelSpeedPi.c WheelSpeedPi.h
  group Drivers/STM32F1xx_HAL_Driver/I2C
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_i2c.c
software components: CMSIS:CORE 4.3.0
